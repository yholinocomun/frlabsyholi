Commit message: modificaciones finales del los archivos

File: lab3/urdf/robot.urdf (robot description, URDF)
Before this commit: robot robot_demo, 3 links, 2 joints
Links:
- removed link base_link
- added link base_footprint
- added link base_link_green; visual cylinder length=0.01 radius=0.2
